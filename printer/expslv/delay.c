/*=============================================================*/
/*                  KD20B Controller Program                   */
/*                  Module Name : SLAVE                        */
/*                  Task   Name : Delay.c                      */
/*                  Programming Date : 1997. 1. 15             */
/*                  Kia Information Systems.                   */
/*                  Printer Development Team.                  */
/*                  Programmed by Shin Jung Wook               */
/*=============================================================*/

/*=============================================================*/
/*                       Include Part                          */
/*=============================================================*/

#include <stdio.h>
#include "define.h"
#include "extern.h"

/*=============================================================*/
/*                     Function Declaration                    */
/*=============================================================*/

Delay(int);
Delay2(int);
Delay3();

/*=============================================================*/
/*                      Delay Routine                          */
/*                    time = 500 per 1.12ms                    */
/*=============================================================*/

Delay(time)
int time;
{
	int m;
   	for(m=0;m<time;m++);
}

/*=============================================================*/
/*                      Delay Routine 2                        */
/*                   time = 100 per 1 sec                      */
/*=============================================================*/

Delay2(time)
int time;
{
	int m,n;
   	for(m=0;m<5000;m++) {
    	for(n=0;n<time;n++);
   	}
}

/*=============================================================*/
/*                     Delay Routine 3                         */
/*                       100ms Delay                           */
/*=============================================================*/

Delay3()
{
	int i,j;
   	for(j=0;j<150;j++) {
    	for(i=0;i<600;i++);
   	}
}
